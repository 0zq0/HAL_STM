#include "stdint.h"
#include "circle_buffer.h"

/*********************************************************************
* 函数名称：circle_buf_Init
* 功能描述：环形缓冲区初始化函数，使用缓冲区前必须调用
* 入口参数：pCircleBuf —— 环形缓冲区结构体指针
*          len       —— 缓冲区的总长度（字节数）
*          buf       —— 实际存储数据的数组首地址
* 返 回 值：无
*********************************************************************/
void circle_buf_Init(p_circle_buf pCircleBuf,uint32_t len,uint8_t *buf)
{
    // ===================== 安全判断 =====================
    // 如果结构体指针为空 或者 数据存储数组为空，直接退出，防止程序崩溃
    if(pCircleBuf == NULL || buf == NULL)
    {
        return;
    }
	
    // ===================== 初始化成员变量 =====================
    pCircleBuf->r = 0;          // 读指针初始化为0，表示从第0个位置开始读
    pCircleBuf->w = 0;          // 写指针初始化为0，表示从第0个位置开始写
    pCircleBuf->len = len;      // 把缓冲区总长度保存到结构体中
    pCircleBuf->buf = buf;      // 把外部定义的数组绑定到缓冲区结构体
}

/*********************************************************************
* 函数名称：circle_buf_read
* 功能描述：从环形缓冲区读取 1 个字节数据
* 入口参数：pCircleBuf —— 环形缓冲区结构体指针
*          pVal      —— 读取到的数据会存放到这个指针指向的变量中
* 返 回 值：CIRCLE_BUF_OK     —— 读取成功
*           CIRCLE_BUF_EMPTY  —— 缓冲区为空，读取失败
*********************************************************************/
int circle_buf_read(p_circle_buf pCircleBuf, uint8_t *pVal)
{
    // ===================== 第一步：空指针防护 =====================
    // 检查：结构体指针、缓冲区、数据存储指针 是否合法
    // 任意一个为空，都直接返回空，避免程序崩溃
    if(pCircleBuf == NULL || pCircleBuf->buf == NULL || pVal == NULL)
    {
        return CIRCLE_BUF_EMPTY;
    }

    // ===================== 第二步：判断缓冲区是否为空 =====================
    // 核心规则：读指针 r == 写指针 w → 缓冲区为空，没有数据可读
    if(pCircleBuf->r == pCircleBuf->w)
    {
        return CIRCLE_BUF_EMPTY; // 空了，无法读取，返回失败
    }

    // ===================== 第三步：读取数据 =====================
    // 从缓冲区数组中，取出 读指针r 指向位置的1字节数据
    // 赋值给 *pVal，把数据传给调用函数的外部变量
    *pVal = pCircleBuf->buf[pCircleBuf->r];

    // ===================== 第四步：读指针向后移动 =====================
    // 读完一个数据，读指针必须向后走一步
    // % 取模运算：到达缓冲区末尾后自动回到0，实现循环效果
    pCircleBuf->r = (pCircleBuf->r + 1) % pCircleBuf->len;

    // 数据读取完成，返回成功
    return CIRCLE_BUF_OK;
}

/*********************************************************************
* 函数名称：circle_buf_write
* 功能描述：向环形缓冲区写入 1 个字节数据
* 入口参数：pCircleBuf —— 环形缓冲区结构体指针
*          val       —— 要写入缓冲区的数据
* 返 回 值：CIRCLE_BUF_OK     —— 写入成功
*           CIRCLE_BUF_FULL   —— 缓冲区已满，写入失败
*********************************************************************/
int circle_buf_write(p_circle_buf pCircleBuf, uint8_t val)
{
    // ===================== 第一步：空指针防护 =====================
    // 检查结构体指针和缓冲区是否合法，不合法直接返回满
    if(pCircleBuf == NULL || pCircleBuf->buf == NULL)
    {
        return CIRCLE_BUF_FULL;
    }

    // ===================== 第二步：判断缓冲区是否已满 =====================
    // 核心规则：(写指针+1) 对长度取余 == 读指针 → 缓冲区满
    // 设计目的：故意留一个空位，区分“空”和“满”两种状态
    if((pCircleBuf->w + 1) % pCircleBuf->len == pCircleBuf->r)
    {
        return CIRCLE_BUF_FULL; // 满了，无法写入，返回失败
    }

    // ===================== 第三步：写入数据 =====================
    // 把要写入的数据 val 存放到缓冲区 写指针w 指向的位置
    pCircleBuf->buf[pCircleBuf->w] = val;

    // ===================== 第四步：写指针向后移动 =====================
    // 写完一个数据，写指针向后走一步
    // % 取模运算：实现指针循环折返，走到末尾自动回到开头
    pCircleBuf->w = (pCircleBuf->w + 1) % pCircleBuf->len;

    // 数据写入完成，返回成功
    return CIRCLE_BUF_OK;
}
